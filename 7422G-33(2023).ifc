Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-04-26T18:56:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 26 18:56:54 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8a4ff089-cb36-42f2-8fd8-901cdd0d1ac6\49ad7276-2eba-46bd-a796-2f5e5e885d83\ifc * Database version: 5507 * Database creation date: Fri Apr 26 18:56:54 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 26 18:56:54 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 26 18:56:54 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 7422G-33 Shower faucet with shower set, 160cc, 7422G-33(2023):7422G-33 Shower faucet with shower set, 160cc:43736
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass - Matt black
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - FaucetNominalDepth: 89.2513 mm; FaucetNominalHeight: 63.4 mm; FaucetNominalWidth: 290 mm; HandShowerNominalDepth: 138 mm; HandShowerNominalHeight: 701 mm; HandShowerNominalWidth: 220.3 mm
Type - General - Author: BIMStone; BIMObjectName: 7422G-33(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 20/04/2024
Type - Green Building Properties - EAN Number: 6414150103278; EN Standard: EN 1111, EN 1112, EN 1113; ETIM Class Number: EC011329 Shower mixing tap; Noise Class: I (ISO 3822) Oras lab.; RSK Number: 8283271; Sales Package dimensions (LxWxH): 745 x 241 x 82; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/7422G-33; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/185205_7422G-33_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/7422G-33
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/7422G-33; 3D View: https://static.oras.com/AR/7422G-33; Catalog Drawing URL: http://static.oras.com/catdrw/7422G-33; Dimension Drawing URL: http://static.oras.com/dimdrw/7422G-33; FDV Document URL: http://www.oras.com/datasheet/7422G-33/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7422G-33; Group: Shower faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/7422G-33; Interactive AR View URL: https://static.oras.com/AR/7422G-33; Manufacturer: Oras; Market: International;Sweden; Mobile Product Information URL: http://mpi.oras.com/7422G-33; Model: 7422G-33 Shower faucet with shower set, 160cc; Name_en: 7422G-33 Shower faucet with shower set, 160cc; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 7422G-33; Product Family: Oras Nova; Product Image URL: http://static.oras.com/image/7422G-33; Product URL: http://static.oras.com/7422G-33; Technical DataSheet URL: http://www.oras.com/datasheet/7422G-33/en; Type Name: 7422G-33 Shower faucet with shower set, 160cc; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass - Matt black
Type - Mechanical - Backflow Prevention EN1717: EB; Connection: Direct connection;Internal thread; Connection Size: M26x1.5; Eco Flow At 300kPa: 0.000988811 m3/s; Flow Rate At 300kPa With Flow Reducers: 0.00501468 m3/s; Hand Shower Size: Ø 70 mm; Installation Type: Wall mounted; Installation Width: CC160 mm; Lever Handle: Temperature control handle;Flow control handle;Eco feature for water flow; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Ceramic head part for flow control;Thermostatic cartridge for automatic temperature control;Non-return valve(s);Litter filter(s); Shower Parts: Hand shower;Shower rail;Adjustable shower rail bracket;Soap dish;Shower hose (1500 mm);Eco flow control; Shower Spray: EcoSpray; Shower Spray Number: 1 shower spray; Surface treatment: Matt black; Temperature: Thermostatic temperature control; Temperature Adjustments: Limitation option for maximum temperature and flow-rate ;Safety stop against scalding at 38°C; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Matt black; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7422G-33(2023); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7422G-33; Name: 7422G-33 Shower faucet with shower set, 160cc; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet: 290x90x65 mm; Shower:220x140x700 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DistanceX-Axis: 300 mm; DistanceY-Axis: 300 mm; Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; HandShowerVisibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm; ShowerDefaultElevation: 1200 mm
Dimensions - Area: 0.335129 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; InletDistance: 160 mm; OutletAngle: 0 deg; Volume: 0.0229824 m3
Identity Data - Mark: 19
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 7422G-33(2023): 7422G-33 Shower faucet with shower set, 160cc; Family and Type: 7422G-33(2023): 7422G-33 Shower faucet with shower set, 160cc; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7422G-33(2023): 7422G-33 Shower faucet with shower set, 160cc; Type Id: 7422G-33(2023): 7422G-33 Shower faucet with shower set, 160cc; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
